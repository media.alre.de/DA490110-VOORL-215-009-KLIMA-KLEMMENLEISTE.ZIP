Properties of the parts of a building model (IFC2X3)

# File
Description: Klemmenleiste, H-/K-Umschaltung über externen Kontakt, max. 5 Raumthermostate und 20 Stellantriebe, IP20, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA490110, Klemmenleiste, H-/K-Umschaltung über externen Kontakt, max. 5 Raumthermostate und 20 Stellantriebe, IP20
In: Raum
Description: Dieses Gerät wurde speziell zur schnellen, übersichtlichen und komfortablen Verdrahtung von 230 VAC Einzelraum-Temperaturreglern mit den zugehörigen Ventilstellantrieben zur ortsfesten Montage entwickelt. Die Heizen-/Kühlen-Umschaltung erfolgt über einen zentralen Kontakt. Als Regler können Heizungsregler mit Umschaltkontakt angeschlossen werden. Hohe Zeit- und Kostenersparnis durch die komfortable Verdrahtung durch schraubenlose Federsteckklemmen sowie die genial schnelle und saubere Montage im Heizkreisverteiler durch die optionalen Magnetfüße. Durch die Verwendung von einem Uhrenregler kann eine Master-Slave-Zeitzone gebildet werden. Die Zeitzone kann auch über einen externen Schaltkontakt an Klemme U auf ECO-Funktion umgeschaltet werden.; Classification: EC010057 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA490110; ModelLabel: VOORL-215.009; GlobalTradeItemNumber: 4050528077486; ProductURL: https://alre.de/produkt_DA490110
Pset_Specification - NominalLength: 0.175 m; NominalWidth: 0.09 m; NominalDepth: 0.055 m; NetWeight: 0.29
Pset_ALRE_ETIM_Properties - Breite: 175; Höhe: 90; Tiefe: 55; Versorgungsspannung: 230; Ausgangsspannung: 230; Kontaktausführung: Schließer (NO); Schutzart (IP): IP20; Max. Spannung der Kontakte: 230; Anzahl der Kanäle/Zone: 5; Max. Kontaktbelastung: 3; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010057; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA490110.pdf
